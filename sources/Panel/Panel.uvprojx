# Keil uVision project Panel.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Panel +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, PANEL, STM32F429xx
  c include: ..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;.\src;..\common;..\common\libs;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\libs\FatFS;..\common\libs\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\libs\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Panel.sct
  group HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_dma.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_hcd.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group src
    ./src/: main.cpp no-warnings.h defines.h
  group Connector/Device
    ../common/Connector/Device/: Messages_.cpp Messages_.h Transceiver_.h Value_.h
    ./src/Connector/Device/: Messages_p.cpp Handlers_p.cpp Handlers_p.h Interface_p.cpp Interface_p.h Transceiver_p.cpp
  group Device
    ./src/Device/: Device.cpp Device.h
  group Display
    ../common/Display/: Colors_.cpp Colors_.h Console_.cpp Console_.h Display_.cpp Display_.h Display_stm_.cpp Primitives_.cpp Primitives_.h Symbols_.cpp Symbols_.h Text_.cpp Text_.h
    ./src/Display/: Painter.cpp Painter.h
  group Display/Font
    ../common/Display/Font/: Font.cpp Font.h FontBig.cpp FontBig.h fontGOSTAU16BOLD.inc fontGOSTB28B.inc FontMid.cpp FontMid.h
  group Display/Pictures
    ./src/Display/Pictures/: Picture.cpp Picture.h Signal1.inc
  group FlashDrive
    ./src/FlashDrive/: FileManager.cpp FileManager.h FlashDrive.cpp FlashDrive.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h Sound.cpp Sound.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: system_stm32f4xx.c startup_stm32f429xx.s
    ./src/: no-warnings.h
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_EEPROM.cpp HAL_FSMC.cpp HAL_IT.cpp HAL_TIM.cpp stm32f4xx_hal_conf.h HAL_PINS.cpp HAL_PINS.h
    ../common/Hardware/HAL/: HAL_SPI1_p_.cpp HAL_RTC_.cpp
  group Hardware/Keyboard
    ../common/Hardware/Keyboard/: Keyboard_.cpp Keyboard_.h
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsDef.h ParameterDrawStruct.cpp ParameterDrawStruct.h
  group Menu/Pages
    ./src/Menu/Pages/: PageMain.cpp Pages.h PageSignal1.cpp PageSignal2a.cpp PageSignal2b.cpp PageSignal3a.cpp PageSignal3b.cpp PageSignal4.cpp PageSignal5a.cpp PageSignal5b.cpp PageSettings.cpp PageInfo.cpp
  group Settings
    ./src/Settings/: Settings.cpp Settings.h
  group SCPI
    ./src/SCPI/: SCPI.cpp SCPI.h
  group VCP
    ../common/VCP/: VCP.cpp VCP.h
  group Utils
    ../common/Utils/: List_.cpp List_.h StringUtils_.cpp StringUtils_.h Math_.cpp Math_.h Stack_.cpp Stack_.h Buffer_.cpp Buffer_.h Debug_.cpp Debug_.h Log_.cpp Log_.h
  group libs/FatFS
    ../common/libs/FatFS/: ffconf.h
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: ff.c ff.h ff_gen_drv.c ff_gen_drv.h diskio.c diskio.h
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group libs/miniz
    ../common/libs/miniz/: miniz.c miniz.h miniz_tinfl.c miniz_tdef.c miniz_zip.c
  group libs/USBD
    ../common/libs/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_desc.cpp usbd_desc.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group libs/USBH
    ../common/libs/USBH/: usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_pipes.h usbh_ctlreq.h usbh_ioreq.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
target Release (6160000::V6.16::ARMCLANG)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: as above
  output: Panel +hex
  c flags: Optim=5 oTime=1 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER, PANEL, STM32F429xx
  c include: ..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;.\src;..\common;..\common\libs;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\libs\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\libs\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\libs\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Panel.sct
