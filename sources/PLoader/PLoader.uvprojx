# Keil uVision project PLoader.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PLoader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER,LOADER,DEBUG,STM32F429xx
  c include: .\src;.\src\Hardware\USBH;.\src\Hardware\FatFS;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\PLoader.sct
  group HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_ll_usb.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c
  group src
    ./src/: main.cpp no-warnings.h defines.h
  group Hardware/HAL
    ../Panel/src/Hardware/HAL/: HAL.h HAL.cpp HAL_TIM.cpp
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h HAL_IT.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: system_stm32f4xx.c startup_stm32f429xx.s
target Release (6210000::V6.21::ARMCLANG)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: as above
  output: PLoader +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, LOADER, STM32F429xx
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\USBH;.\src\Hardware\FatFS;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\PLoader.sct
