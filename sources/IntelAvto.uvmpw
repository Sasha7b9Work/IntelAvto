<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>IntelAvto</WorkspaceName>

  <project>
    <PathAndName>.\Panel\Panel.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\PLoader\PLoader.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\Device\Device.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\FatFs_USBDisk_F4.1.28.1\MDK-ARM\Project.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

</ProjectWorkspace>
